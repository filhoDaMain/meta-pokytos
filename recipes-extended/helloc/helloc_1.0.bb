REPO_URL = "github.com/filhoDaMain/Coconuts2D"
BRANCH = "build-packing-concept"

SRCREV = "1b7ec307eb4a5c7de9632573ef2faa18a4e4625f"
jonas

carlos


